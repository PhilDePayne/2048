# IAR project LPC2104_color_lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2104 Philips LPC2104
  ICCARM.CCDefines: LPC2104
  ICCARM.CCIncludePath2: ..\startup\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: LPC2104
  XLINK.XclFile: LPC2104_Flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: bt.c eeprom.c exampleGame.c hw.c i2c.c key.c lcd.c main.c pong.c select.c snake.c startupDisplay.c uart.c
  group irq_code
    ../irq_code/: irqUart.c
  group linker control
    ./: LPC2104_Flash.xcl
  group pre_emptive_os
    ../pre_emptive_os/: pre_emptive_os.r79
  group startup
    ../startup/: consol.c framework.c lpc2xxx_cstartup.s79
